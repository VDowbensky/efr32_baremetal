# Keil uVision project norailtest.uvprojx, settings and files
target efr32fg1v131 (6160000::V6.16::ARMCLANG)
  device: EFR32FG1V131F128GM32 Silicon Labs
  pack: SiliconLabs.GeckoPlatform_EFR32FG1V_DFP.3.1.0
  cpu: IRAM(0x20000000,0x00004000) IROM(0x00000000,0x00020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: norailtest +hex
  AfterMake: fromelf --bin ".\objects\@L.axf" --output ".\objects\@L.bin"
  c flags: Optim=2 OneElfS=1 v6Lang=4 v6LangP=3 wLevel=3
  c define: EFR32FG1V131F128GM32
  c include: .\startup;.\src;.\inc;.\lib\src;.\lib\inc;.\device;.\periph;.\radio\src;.\radio\inc
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0xfe10000 size 0x2800
  memory RVCT9: RAM 0x20000000 size 0x4000
  memory RVCT10: RAM 0x21000000 size 0x1000
  group src
    ./src/: main.c command_interpreter.c retargetserial.c app_cli.c mcu_memory.c myspi.c myi2c.c spi_ram.c si7210.c sfh7771.c adc.c leds.c atten.c radio_proc.c
    ./inc/: radio_types.h
  group inc
    ./inc/: bsp.h command_interpreter.h app_cli.h mcu_memory.h myspi.h myi2c.h spi_ram.h si7210.h sfh7771.h adc.h leds.h atten.h radio_proc.h
  group lib
    ./lib/src/: em_cmu.c em_emu.c em_system.c em_gpio.c em_usart.c em_int.c em_msc.c em_i2c.c em_adc.c em_letimer.c tempdrv.c
  group startup
    ./startup/: system_efr32fg1v.c startup_efr32fg1v.s
  group radio
    ./radio/src/: generic_phy.c generic_seq.c if_adc.c ir_cal.c lna.c pa.c aux_pll.c phy.c phy_utils.c protimer.c radio.c radio_cmu.c RADIO_pti.c rail_calibration.c rail_diagnostic.c rail_rf.c rail_rf_hal.c rail_rx.c rail_tx.c rf_rand.c rf_test.c rfsense.c rtccsync.c synth.c tempcal.c nibblebits.c
    ./src/: rail_callbacks.c
software components: Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0
