# Keil uVision project radiotest.uvprojx, settings and files
target efr32fg1v131 (6220000::V6.22::ARMCLANG)
  device: EFR32FG1V131F128GM32 Silicon Labs
  pack: SiliconLabs.GeckoPlatform_EFR32FG1V_DFP.2.7.0
  cpu: IRAM(0x20000000,0x00004000) IROM(0x00000000,0x00020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: radiotest +hex
  AfterMake: fromelf --bin ".\objects\@L.axf" --output ".\objects\@L.bin"
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 v6Lto=1 wLevel=3
  c define: EFR32FG1V131F128GM32
  c include: .\inc;.\RTE;..\radio\inc;..\lib\inc;..\inc;..\chip;..\startup
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0xfe10000 size 0x2800
  memory RVCT9: RAM 0x20000000 size 0x4000
  group lib
    ../lib/src/: em_cmu.c em_system.c em_gpio.c em_usart.c em_int.c em_msc.c em_i2c.c em_adc.c em_letimer.c em_emu.c gpiointerrupt.c em_core.c em_timer.c
  group startup
    ../startup/: system_efr32fg1v.c startup_efr32fg1v.s
  group common
    ../src/: command_interpreter.c leds.c main.c mcu_memory.c retargetserial.c radio_proc.c cli_common.c
  group device
    ./src/: adc.c app_cli.c bsp.c timer1.c
  group radio
    ../radio/src/: generic_seq.c pa.c protimer.c radio_frc.c radio_phy.c radio_rx.c radio_timing.c radio_tx.c AGC.c CRC.c FRAME.c RFIF.c WHITE.c SYNTH.c BUFC.c RADIO_config.c MODEM.c UTILS.c
software components: Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0
